# Keil uVision project Rock700AMP.uvproj, settings and files
target NAD_C358 (ARM-ADS)
  device: TM4C1290NCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: NAD_C358
  c flags: Optim=1
  c define: rvmdk PART_TM4C1290NCZAD RTOS_FREERTOS  TARGET_IS_SNOWFLAKE_RA0
  c include: .\FreeRTOS\include;.\inc;.\startup;.\driverlib;.\Application;.\FreeRTOS\portable;.\Task;.\driver
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\build\Rock700AMP.sct
  group startup
    ./startup/: startup_rvmdk.S common_head.h sys_config.h bsp.c sys_database.h bsp.h
  group driverlib
    ./driverlib/: driverlib.lib
  group RTOS
    ./FreeRTOS/: timers.c croutine.c list.c queue.c tasks.c
    ./FreeRTOS/portable/: port.c heap_4.c
  group Application
    ./Application/: main.c serial.c OSAL_Console.c OSAL_Utility.c OSAL_RingBuf.c OSAL_Soft_IIC.c osal_timers.c
  group Task
    ./Task/: Console_Task.c System_Task.c Display_Task.c
  group driver
    ./driver/: EPRom_driver.c lcd_driver.c
